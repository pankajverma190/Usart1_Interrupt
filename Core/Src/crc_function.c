/*
 * crc_function.c
 *
 *  Created on: 19-May-2021
 *      Author: pankaj.kumar
 */

#include"include_file.h"
#define LAST_TABLE_ELEMENT_LOW 				(ubyte)0x2
#define LAST_TABLE_ELEMENT_HIGH 			(ubyte)0x2
unsigned char crc_buff[4];

uint16_t look_table_high[255]=
	{
	0x00,0x80,0x80,0x00,0x80,0x00,0x00,0x80,0x80,0x00,0x00,0x80,0x00,0x80,0x80,0x00,
	0x80,0x00,0x00,0x80,0x00,0x80,0x80,0x00,0x00,0x80,0x80,0x00,0x80,0x00,0x00,0x80,
	0x80,0x00,0x00,0x80,0x00,0x80,0x80,0x00,0x00,0x80,0x80,0x00,0x80,0x00,0x00,0x80,
	0x00,0x80,0x80,0x00,0x80,0x00,0x00,0x80,0x80,0x00,0x00,0x80,0x00,0x80,0x80,0x00,
	0x81,0x01,0x01,0x81,0x01,0x81,0x81,0x01,0x01,0x81,0x81,0x01,0x81,0x01,0x01,0x81,
	0x01,0x81,0x81,0x01,0x81,0x01,0x01,0x81,0x81,0x01,0x01,0x81,0x01,0x81,0x81,0x01,
	0x01,0x81,0x81,0x01,0x81,0x01,0x01,0x81,0x81,0x01,0x01,0x81,0x01,0x81,0x81,0x01,
	0x81,0x01,0x01,0x81,0x01,0x81,0x81,0x01,0x01,0x81,0x81,0x01,0x81,0x01,0x01,0x81,
	0x83,0x03,0x03,0x83,0x03,0x83,0x83,0x03,0x03,0x83,0x83,0x03,0x83,0x03,0x03,0x83,
	0x03,0x83,0x83,0x03,0x83,0x03,0x03,0x83,0x83,0x03,0x03,0x83,0x03,0x83,0x83,0x03,
	0x03,0x83,0x83,0x03,0x83,0x03,0x03,0x83,0x83,0x03,0x03,0x83,0x03,0x83,0x83,0x03,
	0x83,0x03,0x03,0x83,0x03,0x83,0x83,0x03,0x03,0x83,0x83,0x03,0x83,0x03,0x03,0x83,
	0x02,0x82,0x82,0x02,0x82,0x02,0x02,0x82,0x82,0x02,0x02,0x82,0x02,0x82,0x82,0x02,
	0x82,0x02,0x02,0x82,0x02,0x82,0x82,0x02,0x02,0x82,0x82,0x02,0x82,0x02,0x02,0x82,
	0x82,0x02,0x02,0x82,0x02,0x82,0x82,0x02,0x02,0x82,0x82,0x02,0x82,0x02,0x02,0x82,
	0x02,0x82,0x82,0x02,0x82,0x02,0x02,0x82,0x82,0x02,0x02,0x82,0x02,0x82,0x82
	};

uint16_t look_table_low [255]=
	{
	0x00,0x05,0x0f,0x0a,0x1b,0x1e,0x14,0x11,0x33,0x36,0x3c,0x39,0x28,0x2d,0x27,0x22,
	0x63,0x66,0x6c,0x69,0x78,0x7d,0x77,0x72,0x50,0x55,0x5f,0x5a,0x4b,0x4e,0x44,0x41,
	0xc3,0xc6,0xcc,0xc9,0xd8,0xdd,0xd7,0xd2,0xf0,0xf5,0xff,0xfa,0xeb,0xee,0xe4,0xe1,
	0xa0,0xa5,0xaf,0xaa,0xbb,0xbe,0xb4,0xb1,0x93,0x96,0x9c,0x99,0x88,0x8d,0x87,0x82,
	0x83,0x86,0x8c,0x89,0x98,0x9d,0x97,0x92,0xb0,0xb5,0xbf,0xba,0xab,0xae,0xa4,0xa1,
	0xe0,0xe5,0xef,0xea,0xfb,0xfe,0xf4,0xf1,0xd3,0xd6,0xdc,0xd9,0xc8,0xcd,0xc7,0xc2,
	0x40,0x45,0x4f,0x4a,0x5b,0x5e,0x54,0x51,0x73,0x76,0x7c,0x79,0x68,0x6d,0x67,0x62,
	0x23,0x26,0x2c,0x29,0x38,0x3d,0x37,0x32,0x10,0x15,0x1f,0x1a,0x0b,0x0e,0x04,0x01,
	0x03,0x06,0x0c,0x09,0x18,0x1d,0x17,0x12,0x30,0x35,0x3f,0x3a,0x2b,0x2e,0x24,0x21,
	0x60,0x65,0x6f,0x6a,0x7b,0x7e,0x74,0x71,0x53,0x56,0x5c,0x59,0x48,0x4d,0x47,0x42,
	0xc0,0xc5,0xcf,0xca,0xdb,0xde,0xd4,0xd1,0xf3,0xf6,0xfc,0xf9,0xe8,0xed,0xe7,0xe2,
	0xa3,0xa6,0xac,0xa9,0xb8,0xbd,0xb7,0xb2,0x90,0x95,0x9f,0x9a,0x8b,0x8e,0x84,0x81,
	0x80,0x85,0x8f,0x8a,0x9b,0x9e,0x94,0x91,0xb3,0xb6,0xbc,0xb9,0xa8,0xad,0xa7,0xa2,
	0xe3,0xe6,0xec,0xe9,0xf8,0xfd,0xf7,0xf2,0xd0,0xd5,0xdf,0xda,0xcb,0xce,0xc4,0xc1,
	0x43,0x46,0x4c,0x49,0x58,0x5d,0x57,0x52,0x70,0x75,0x7f,0x7a,0x6b,0x6e,0x64,0x61,
	0x20,0x25,0x2f,0x2a,0x3b,0x3e,0x34,0x31,0x13,0x16,0x1c,0x19,0x08,0x0d,0x07
	};

uint16_t crc_high_lookup[] =
	{
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
	0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
	0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,
	0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81,
	0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,
	0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
	0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
	0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,
	0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
	0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,
	0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
	0x40
	};

uint16_t crc_low_lookup[] =
	{
	0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7, 0x05, 0xC5, 0xC4,
	0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,
	0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD,
	0x1D, 0x1C, 0xDC, 0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
	0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32, 0x36, 0xF6, 0xF7,
	0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,
	0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE,
	0x2E, 0x2F, 0xEF, 0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
	0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1, 0x63, 0xA3, 0xA2,
	0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,
	0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB,
	0x7B, 0x7A, 0xBA, 0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
	0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0, 0x50, 0x90, 0x91,
	0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,
	0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88,
	0x48, 0x49, 0x89, 0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
	0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83, 0x41, 0x81, 0x80,
	0x40
	};
//#######################################################################################
//								FUNCTION DETAILS
//#######################################################################################
//	NAME		:crc_generate_microchip
//	ARGUMENTS	:
//	RETURN TYPE	:
//	DESCRIPTION	:

//#######################################################################################
void crc_generate(ubyte *rec_buff_address, uinteger rec_buff_length)
{															// CRC_initialization
	ubyte dup_crc_byte = 0;
	ubyte crc_high = 0;
	ubyte crc_low = 0;
	ubyte crc_byte = 0;
	ubyte temp = 0;                  							// rec_buff_length

	if(rec_buff_length >= 3)										// if data bytes > 2 no need to append zero, here
	{
		dup_crc_byte = crc_byte  = *rec_buff_address++;				// CRC buff is initialized by first data byte
		crc_high =	*rec_buff_address++;							// CRC HIGH is initialized by second data byte
		crc_low   =	*rec_buff_address;							// CRC LOW is initialized by third data byte
		rec_buff_length = rec_buff_length - 2;
		temp = 0x02;
	}
	else if(rec_buff_length == 2)									// if data bytes = 2 append one zero
	{
		dup_crc_byte = crc_byte = *rec_buff_address++;				// CRC buff is initialized by first data byte
		crc_high = *rec_buff_address++;							// CRC HIGH is initialized by second data byte
		crc_low = 0x00;									// CRC LOW is initialized by ZERO
		rec_buff_length = 1;
		temp=0x02;
	}
	else if(rec_buff_length==1)									// if data bytes = 1 append two zeros
	{
		dup_crc_byte = crc_byte = *rec_buff_address++;				// CRC buff is initialized by the data byte
		crc_high =	0x00;									// CRC HIGH is initialized by ZERO
		*rec_buff_address++;
		crc_low = 0x00;									// CRC LOW is initialized by ZERO
		rec_buff_length = 0x00;
		temp=0x01;
	}
// Check if last crc_byte points to last element in table .These elements
// cannot  be read from the lookup table,because they are beyond the program memory page.
append_zero:
	while(rec_buff_length != 0x00)
	{
		dup_crc_byte = dup_crc_byte ^ 0xFF;					// checking if the byte is 0xFF
		if(dup_crc_byte == 0x00)
		{
			crc_high = crc_high ^ LAST_TABLE_ELEMENT_HIGH; 	// yes ,get the last element for high byte ,XOR  with high byte.
			crc_low = crc_low ^ LAST_TABLE_ELEMENT_LOW;		// get last element for low byte  ,XOR with low byte.
			rec_buff_length--;
			dup_crc_byte = crc_byte = crc_high;		 		// copy high byte to crc_byte.
			crc_high = crc_low;								// copy low byte to crc_high.
			*rec_buff_address++;											// point to the next data byte.
			crc_low = *rec_buff_address;							// offset value is loaded.
			goto append_zero;
		}
		crc_high = look_table_high[crc_byte] ^ crc_high; 	// get value for high byte
		// XOR table element with high byte.
		crc_low	 = look_table_low[crc_byte] ^ crc_low; 		// get value for low byte
		rec_buff_length--;										// decrement data byte.
		dup_crc_byte = crc_byte = crc_high;					// copy high byte to crc_byte.
		crc_high = crc_low;								// copy low byte to crc_high.
		*rec_buff_address++;												// point to the next data byte.
		crc_low = *rec_buff_address;							// offset value is loaded.
	}
	while(temp != 0x00)										// ie 3-1=2 append two bytes with zeros.
	{
		crc_low = 0x00;										// appending zero after the transmit_buff bytes
		rec_buff_length++;										// increment for additional iteration
		temp--;
		goto append_zero;
	}
	crc_low	= crc_high;
	crc_high = crc_byte;				//to be appended before transmitting the transmit_buff.
	*rec_buff_address--;
	*rec_buff_address--;
	*rec_buff_address = crc_high;				//append at th last of buffer.
	*rec_buff_address++;
	*rec_buff_address = crc_low;
}
//#######################################################################################

//void crc_generate_modbus(ubyte *rec_buff_address, uinteger rec_buff_length)
//{
//	ubyte crc_high = 0xFF;
//	ubyte crc_low = 0xFF;
//	ubyte crc_index;
//
//	while(rec_buff_length--)
//	{
//		crc_index = crc_low ^ *rec_buff_address++;
//		crc_low = crc_high ^ crc_high_lookup[crc_index];
//		crc_high = crc_low_lookup[crc_index];
//	}
//	*rec_buff_address++ = crc_low;
//	*rec_buff_address = crc_high;
//}
//#######################################################################################
//								FUNCTION DETAILS
////#######################################################################################
////	NAME		: crc_generate_ascii_microchip
////	ARGUMENTS	: Key pad entries
////	RETURN TYPE	: None
////	DESCRIPTION	:
//
////#######################################################################################
void crc_generate_ascii(ubyte *rec_buff_address, uinteger rec_buff_length)
{
    ubyte crc[4] = {0};
	crc_generate(rec_buff_address,rec_buff_length);
	dec_byte_to_char_fixed(rec_buff_address + rec_buff_length,crc,2);
	dec_byte_to_char_fixed(rec_buff_address + rec_buff_length + 1,&crc[2],2);
    str_copy_ram_cnt(crc,rec_buff_address + rec_buff_length,4);
    str_copy_ram_cnt(crc,crc_buff,4);
  //  str_copy_ram_cnt(crc,gsm.crc_data,4);
}
//#######################################################################################
//								FUNCTION DETAILS
//#######################################################################################
//	NAME		: crc_generate_ascii_modbus
//	ARGUMENTS	: Key pad entries
//	RETURN TYPE	: None
//	DESCRIPTION	:

//#######################################################################################
//void crc_generate_ascii_modbus(ubyte *rec_buff_address, uinteger rec_buff_length)
//{
//	ubyte crc_high = 0xFF;
//	ubyte crc_low = 0xFF;
//	ubyte crc_index;
//
//	while(rec_buff_length--)
//	{
//		crc_index = crc_low ^ *rec_buff_address++;
//		crc_low = crc_high ^ crc_high_lookup[crc_index];
//		crc_high = crc_low_lookup[crc_index];
//	}
//	dec_byte_to_char_fixed(&crc_low,rec_buff_address,2);
//	rec_buff_address += 2;
//	dec_byte_to_char_fixed(&crc_high,rec_buff_address,2);
//	rec_buff_address += 2;
//}

//void crc_generate_ascii_modbus(ubyte *rec_buff_address, uinteger rec_buff_length)
//{
//	ubyte crc_high = 0xFF;
//	ubyte crc_low = 0xFF;
//	ubyte crc_index;
//
//	while(rec_buff_length--)
//	{
//		crc_index = crc_low ^ *rec_buff_address++;
//		crc_low = crc_high ^ crc_high_lookup[crc_index];
//		crc_high = crc_low_lookup[crc_index];
//	}
//	dec_byte_to_char_fixed(&crc_low,rec_buff_address,3);
//	rec_buff_address += 3;
//	dec_byte_to_char_fixed(&crc_high,rec_buff_address,3);
//	rec_buff_address += 3;
//}
//#######################################################################################
//								FUNCTION DETAILS
//#######################################################################################
//	NAME		: generate_crc
//	ARGUMENTS	: Key pad entries
//	RETURN TYPE	: None
//	DESCRIPTION	:

//#######################################################################################
void generate_crc(ubyte *rec_buff_address, uinteger rec_buff_length)
{

	crc_generate_ascii(rec_buff_address,rec_buff_length);

}

//void generate_crc(ubyte *rec_buff_address, uinteger rec_buff_length,ubyte crc_type)
//{
//    switch(crc_type)
//    {
//        case MODBUS:
//            crc_generate_modbus(rec_buff_address,rec_buff_length);
//            break;
////        case MICROCHIP:
////            crc_generate_microchip(rec_buff_address,rec_buff_length);
////            break;
////        case ASCII_MICROCHIP:
////            crc_generate_ascii_microchip(rec_buff_address,rec_buff_length);
////            break;
//        case ASCII_MODBUS:
//            crc_generate_ascii_modbus(rec_buff_address,rec_buff_length);
//            break;
//    }
//}
//#######################################################################################
//								FUNCTION DETAILS
//#######################################################################################
//	NAME		: verify_crc
//	ARGUMENTS	: Key pad entries
//	RETURN TYPE	: None
//	DESCRIPTION	:

//#######################################################################################
uint8_t verify_crc(ubyte *rec_buff_address, uinteger rec_buff_length)
{
    ubyte crc[4] = {0};
    str_copy_ram_cnt(rec_buff_address+rec_buff_length,crc,4);
    crc_generate_ascii(rec_buff_address,rec_buff_length);
    if(str_comp_ram(crc_buff,crc,4))
    	return(1);
    else
    	return 0;
//    if(str_comp_ram(gsm.crc_data,crc,4))
//        	return(1);
//    else
//    	return 0;
}

//unsigned verify_crc(ubyte *rec_buff_address, uinteger rec_buff_length,ubyte crc_type)
//{
//    ubyte crc[6] = {0};
//    switch(crc_type)
//    {
//        case MODBUS:
//            crc[0] = *(rec_buff_address+rec_buff_length);
//            crc[1] = *(rec_buff_address+rec_buff_length + 1);
//            crc_generate_modbus(rec_buff_address,rec_buff_length);
//            if(crc[0] == *(rec_buff_address+rec_buff_length) && crc[1] == *(rec_buff_address+rec_buff_length + 1))
//                return(1);
//            break;
////        case MICROCHIP:
////            crc[0] = *(rec_buff_address+rec_buff_length);
////            crc[1] = *(rec_buff_address+rec_buff_length + 1);
////            crc_generate_microchip(rec_buff_address,rec_buff_length);
////            if(crc[0] == *(rec_buff_address+rec_buff_length) && crc[1] == *(rec_buff_address+rec_buff_length + 1))
////                return(1);
////            break;
////        case ASCII_MICROCHIP:
////            str_copy_ram_cnt(rec_buff_address,crc,6);
////            crc_generate_ascii_microchip(rec_buff_address,rec_buff_length);
////            if(str_comp_ram(rec_buff_address+rec_buff_length,crc,6))
////                return(1);
////            break;
//        case ASCII_MODBUS:
//            str_copy_ram_cnt(rec_buff_address,crc,6);
//            crc_generate_ascii_modbus(rec_buff_address,rec_buff_length);
//            if(str_comp_ram(rec_buff_address+rec_buff_length,crc,6))
//                return(1);
//            break;
//    }
//    return(0);
//}
//#######################################################################################
//#######################################################################################

